# Keil uVision project SmartBox.uvprojx, settings and files
target SmartBOx (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SmartBox +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin --output ./out/@L.bin ./Objects/@L.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group src
    ./USER/: main.c appconfig.c appconfig.h IAP.c IAP.h flash.c flash.h
  group utils
    ./USER/: Logs.h delay.h delay.c logs.c
  group timer
    ./USER/: timer.c timer.h
  group usart
    ./USER/: USART.c USART.h
  group at
    ./USER/: AtParser.c AtParser.h connect.c connect.h
software components: CMSIS:CORE 5.0.0, Security:mbed TLS 2.2.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
